# Keil uVision project gateway.uvprojx, settings and files
target CH579 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CH579F WCH
  pack: Keil.WCH57x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3E800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gateway +hex
  c flags: uC99=1 v6Lang=1 v6LangP=1
  c define: __CH579__;DEBUG
  c include: .\src\hal;.\src\hal\bus;.\src\hal\queue;.\src\hal\comm;.\src\hal\frame;.\src\hal\uart;.\src\hal\timer;.\src\core;.\src\modules;.\src\brands;.\app;.\bsp\CH579\StdPeriphDriver\inc;.\lib\CMSIS\Include;.\lib\FreeRTOS\include;.\lib\FreeRTOS;.\lib\FreeRTOS\Portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ./app/: main.c hvac_init.c debug.c isr.c
  group HAL/queue
    ./src/hal/queue/: ring.c frame_queue.c
  group HAL/bus
    ./src/hal/bus/: bus.c
  group HAL/comm
    ./src/hal/comm/: decoder.c encoder.c uart_decoder.c uart_encoder.c
  group HAL/frame
    ./src/hal/frame/: receiver.c receiver_timeout.c sender.c
  group HAL/uart
    ./src/hal/uart/: uart.c uart_instance.c uart_ch579.c
  group HAL/timer
    ./src/hal/timer/: timer.c timer_instance.c timer_ch579.c timer_hw.c timer_soft.c
  group core
    ./src/core/: module.c gateway_device.c
  group modules
    ./src/modules/: ac_module.c wireless_module.c third_party_module.c wifi_module.c debug_module.c
  group brands
    ./src/brands/: ac_gree.c
  group FreeRTOS
    ./lib/FreeRTOS/: freertos_port.c
  group SRC/Startup
    ./bsp/CH579/: startup_ARMCM0.s
  group SRC/StdPeriphDriver
    ./bsp/CH579/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart0.c CH57x_uart1.c CH57x_uart2.c CH57x_uart3.c CH57x_int.c CH57x_flash.c CH57x_adc.c CH57x_timer0.c CH57x_timer1.c CH57x_timer2.c CH57x_timer3.c CH57x_pwm.c
